<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\M1CN016RE_Controller.ewp</path>
  </project>
  <batchBuild />
</workspace>
